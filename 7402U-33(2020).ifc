Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-03-01T13:45:40
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 01 13:45:40 2021 * Host: DESKTOP-JA1LLOH * Database: C:\Users\Vlad\AppData\Local\Temp\{AC853FF9-F07D-48E1-8C0F-9F408DAA8013}\ifc * Database version: 5507 * Database creation date: Mon Mar 01 13:45:38 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Mar 01 13:45:38 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 01 13:45:38 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 7402U-33 Shower system, 7402U-33(2020):7402U-33 Shower system:355773
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - NominalDepth: 545.7 mm; NominalHeight: 1165.2 mm; NominalWidth: 290.2 mm; Projection: 436460 mm
Type - General - Author: BIMStone; BIMObjectName: 7402U-33(2020); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_81; Uniclass2015Description: Shower thermostatic water supply sets; Uniclass2015Reference: Pr_40_20_87_81; Version: 1; VersionDate: 16/02/2021
Type - Green Building Properties - Approval KIWA SE Type Approval: 1664; Backflow Prevention EN1717: EB; Customs Code: 84818011; EAN Number: 6414150098376; EN Standard: EN 1111
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/7402U-33; Catalog Drawing URL: http://static.oras.com/catdrw/7402U-33; Class: Thermostatic; Dimension Drawing URL: http://static.oras.com/dimdrw/7402U-33; FDV Document URL: http://www.oras.com/datasheet/7402U-33/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/7402U-33; Group: Shower systems; Manufacturer: Oras; Market: INT;FIN;SWE;DNK;POL;RUS;EST;LTU;LVA;UKR; Model: 7402U-33 Shower system; Name_en: 7402U-33 Shower system; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 1154 x 383 x 98; Package Weight: 5.35 kg; Product Code: 7402U-33; Product Datasheet: http://www.oras.com/datasheet/7402U-33/en; Product Family: Oras Nova; Product Image URL: http://static.oras.com/image/7402U-33; Product URL: http://static.oras.com/7402U-33; Technical DataSheet URL: http://www.oras.com/datasheet/7402U-33/en; Type Name: 7402U-33 Shower system
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Can be shortened; Connection: Eccentric unions; Connection Size: G1/2; Diverter: Integrated diverter / Volume control; DN Size: DN 15; Flow Rate At 300kPa: 0.00883785 m3/s; Hand Shower Size: Ø 95 mm; Installation and Maintenance: http://static.oras.com/manual/7402U-33; Installation Type: Wall mounted; Installation Width: CC150± 15 mm; Lever Handle: Temperature control handle;Flow control handle; Max. Hot Water Supply: 65 kg/K/s3; Mechanical Parts: Ceramic head part;Non-return valve(s);Litter filter(s); Noise Class: I (ISO 3822); Over Head Shower Size: Ø 200 mm; Pressure Loss With Flow 02ls: 180000 Pa; Shower Parts: Hand shower;Shower rail;Shower head;Shower Hose (1750 mm);Wall distance adjustable;;; Shower Spray: Intense; Shower Spray Number: 1Spray; Spare Parts: http://static.oras.com/sp/7402U-33; Temperature Adjustments: Thermostatic safety stop at 38°C;THERMO COOL
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 7402U-33(2020); Features: Thermostatic; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 7402U-33; Name: 7402U-33 Shower system; ReplacementCost: n/a; Shape: Sculptured; Size: 290x545x1165 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 1.13508 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 20 mm; OutletAngle: 0 deg; Volume: 0.184515 m3
Identity Data - Mark: 10
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 7402U-33(2020): 7402U-33 Shower system; Family and Type: 7402U-33(2020): 7402U-33 Shower system; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 7402U-33(2020): 7402U-33 Shower system; Type Id: 7402U-33(2020): 7402U-33 Shower system; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
